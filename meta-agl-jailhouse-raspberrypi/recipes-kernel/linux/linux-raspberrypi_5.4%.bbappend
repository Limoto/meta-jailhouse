LINUX_VERSION = "5.4.49"
SRCREV = "ddf7285e0f880a993395a373e91339956de60f54"

require recipes-kernel/linux/linux-jailhouse-5.4.inc