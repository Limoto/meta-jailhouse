# required for Jailhouse to work with the supplied cell confiugrations
CMDLINE_append = " mem=768M"